# directfb with tslib plugin
PACKAGECONFIG:append = " linuxinput tslib"

